# Keil uVision project XpLLC474_v0.1.uvprojx, settings and files
target XpLLC474_v0.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474RCTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8022000-0x803AFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: XpLLC474_v0.1 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../AppUser;../common;../OtaGateway;../User;../Driver/SPI;../Driver/mx25L1606E;../Service/CRC
  library: MicroLIB
  memory RVCT4: ROM 0x8022000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: APPA2.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group AppUser
    ../AppUser/: ConsoleFast.c ConsoleSlow.c MODBUS_SLAVE.c CAN_Control_2800W.c mathR02.c user_sample.c operateStatus.c ProtectionLLC.c
  group math
    ../AppUser/: Sr_Handle_N.c
  group OtaGateway
    ../OtaGateway/: OtaGw.c LlcOta.c HostX1JumpShutdown.c CanFdTxQueue.c
  group common
    ../common/: HostX1Gate.c HostOtaHandoff.c HostSlotValidate.c HostProgStatusInit.c OtaHandoffDevType.c HostA2Inquire.c HostA2FactoryInfo.c
  group User
    ../User/: UpgradeMsgSaveFunctionDf.c
  group Driver
    ../Driver/SPI/: Flash_spi.c
    ../Driver/mx25L1606E/: mx25L1606E.c
  group Service
    ../Service/CRC/: crc16.c
target NoBoot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474RCTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.1.0
  cpu: as above
  output: XpLLC474_v0.1 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,NO_BOOT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: APPA2.sct
software components: CMSIS:CORE 4.3.0
